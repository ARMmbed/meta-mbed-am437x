
RDEPENDS_${PN}_remove = "\
    thttpd \
    "

